# Keil uVision project UART_IDLE_NVIC.uvprojx, settings and files
target projectgroup (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MM32F103CBT MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,F103_N_VERSION
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\..\..\..\..\Device\MM32F103\HAL_lib\inc;..\..\..\..\..\Device\MM32F103\Include;..\HARDWARE\LED;..\HARDWARE\UART;..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\HARDWARE\TIM2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32F103/Source/: system_MM32F103.c
    ../../../../../Device/MM32F103/Source/KEIL_StartAsm/: startup_MM32F103.s
  group HALlib
    ../../../../../Device/MM32F103/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart_nvic.c
    ../HARDWARE/TIM2/: tim2.c
  group README
    ../: README.TXT
