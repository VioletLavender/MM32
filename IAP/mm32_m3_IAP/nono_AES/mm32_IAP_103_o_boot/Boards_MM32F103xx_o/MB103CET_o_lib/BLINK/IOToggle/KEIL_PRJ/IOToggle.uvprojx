# Keil uVision project IOToggle.uvprojx, settings and files
target MM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.4
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F103xCxE_o\HAL_lib\inc;..\..\..\..\..\Device\MM32F103xCxE_o\Include;..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\USER;..\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c common.c ymodem.c upload.c download.c aes.c
  group STARTUP
    ../../../../../Device/MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../../../../../Device/MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
  group HALlib
    ../../../../../Device/MM32F103xCxE_o/HAL_lib/src/: HAL_aes.c HAL_flash.c HAL_gpio.c HAL_misc.c HAL_rcc.c HAL_syscfg.c HAL_uart.c
