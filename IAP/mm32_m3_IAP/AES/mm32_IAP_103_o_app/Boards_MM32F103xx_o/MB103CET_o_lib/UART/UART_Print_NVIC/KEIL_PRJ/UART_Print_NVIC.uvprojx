# Keil uVision project UART_Print_NVIC.uvprojx, settings and files
target MM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.4
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: C:\Users\24716\Desktop\mm32_IAP\AES\mm32_IAP_103_o_app\Boards_MM32F103xx_o\MB103CET_o_lib\UART\UART_Print_NVIC\KEIL_PRJ\obj\DebugInFlash\Hex2Bin.exe   @L.hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F103xCxE_o\HAL_lib\inc;..\..\..\..\..\Device\MM32F103xCxE_o\Include;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
  group STARTUP
    ../../../../../Device/MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../../../../../Device/MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
  group HALlib
    ../../../../../Device/MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
