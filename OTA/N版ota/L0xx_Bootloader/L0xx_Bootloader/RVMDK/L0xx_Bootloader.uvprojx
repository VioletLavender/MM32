# Keil uVision project L0xx_Bootloader.uvprojx, settings and files
target MM32L073 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: L0xx_Bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\MM32L0xx\HAL_lib\inc;..\..\Device\MM32L0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group USER
    ../User/: main.c MM32L073_it.c
  group HALlib
    ../../Device/MM32L0xx/HAL_lib/src/: HAL_flash.c HAL_misc.c HAL_rcc.c HAL_syscfg.c HAL_gpio.c
  group STARTUP
    ../../Device/MM32L0xx/Source/: system_MM32L0xx.c
    ../../Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
software components: CMSIS:CORE 5.4.0
