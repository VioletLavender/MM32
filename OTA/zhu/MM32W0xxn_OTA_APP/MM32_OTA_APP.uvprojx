# Keil uVision project MM32_OTA_APP.uvprojx, settings and files
target APP-OTA (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mg_mass_production.hex +hex
  AfterMake: fromelf --bin --output .\Obj\APP-OTA.bin .\Obj\APP-OTA.axf
  c flags: v6Lang=1 v6LangP=1
  c define: DEVICE_INFO_SUPPORT OTA_SUPPORT
  c include: .\BSP;.\Src\inc;.\MM32x031\CMSIS\KEIL_CORE;.\Device\MM32L0xx\HAL_lib\inc;.\Device\MM32L0xx\Include;.\Device\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8001010 size 0xeff0
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group startup
    ./Device/MM32L0xx/Source/: system_MM32L0xx.c
    ./Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group BSP
    ./BSP/: BSP_OTA.c MM32W072_it.c
  group HALlib
    ./Device/MM32L0xx/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_memprotect.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group src
    ./Src/: app_OTA.c main_OTA.c
    ./Src/lib/: mg_BLEOTA_lib_m0.lib
