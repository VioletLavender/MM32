# Keil uVision project OTA_BOOT.uvprojx, settings and files
target APP-OTA (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: OTA_BOOT +hex
  AfterMake: fromelf --bin --output .\Obj\OTA_BOOT.bin .\Obj\OTA_BOOT.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32L0xx\HAL_lib\inc;..\..\Device\MM32L0xx\Include;..\KEIL_PRJ;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../../Device/MM32L0xx/Source/: system_MM32L0xx.c
    ../../Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group HALlib
    ../../Device/MM32L0xx/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_memprotect.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../USER/: main.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/: MM32L073_it.c
