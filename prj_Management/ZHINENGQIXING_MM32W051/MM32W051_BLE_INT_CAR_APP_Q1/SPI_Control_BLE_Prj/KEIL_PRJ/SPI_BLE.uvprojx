# Keil uVision project SPI_BLE.uvprojx, settings and files
target MM32W0xx_q (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.6
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MB031 +hex
  c flags: Optim=1 wLevel=1
  c define: DEVICE_INFO_SUPPORT USE_UART
  c include: ..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\HARDWARE\SPI;..\HARDWARE\CALLBACK;..\HARDWARE\IIC;..\HARDWARE\IRQ;..\SRC_LIB;..\HARDWARE\RCC_MCU;..\HARDWARE\AT_CMD;..\SRC_LIB\lib;..\SRC_LIB\inc;..\HARDWARE\LED_MESH;..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F031x4x6_q\Include;..\..\Device\MM32F031x4x6_q\HAL_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../../Device/MM32F031x4x6_q/Source/: system_MM32F031x4x6_q.c
    ../../Device/MM32F031x4x6_q/Source/KEIL_StartAsm/: startup_MM32F031x4x6_q.s
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/UART/: uart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HALlib
    ../../Device/MM32F031x4x6_q/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/CALLBACK/: callback.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/IRQ/: IRQ_RF.c
    ../HARDWARE/RCC_MCU/: rcc.c
    ../HARDWARE/AT_CMD/: AT_CMD.c
    ../HARDWARE/LED_MESH/: led_mesh.c
  group SRC_LIB
    ../SRC_LIB/: app.c
    ../SRC_LIB/lib/: mg_BLE_lib_m0.lib
  group README
    ../HARDWARE/README/: README.txt
